# Repository Pixeljoch/Robocup_PCB

## KiCad design IR_Board/IR_Board.kicad_pcb

Parts:
C1: 47n; C_0201_0603Metric
C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15: 220n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: B; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: A; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: CONN_OUT; Hirose_DF11-16DP-2DSA_2x08_P2.00mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14: FDG6335N; SOT-363_SC-70-6
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_SPDT; EG1218
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14: TSSP58038; Vishay_MINIMOLD-3Pin

Connections:
+3V3: C1.2, J1.10, R9.2, SW1.2 (B), U1.3 (Vs), U2.3 (Vs), U3.3 (Vs), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs)
A: Q1.2 (G), Q2.2 (G), Q3.2 (G), Q4.2 (G), Q5.2 (G), Q6.2 (G), Q7.2 (G), Q8.2 (G), Q9.2 (G), Q10.2 (G), Q11.2 (G), Q12.2 (G), Q13.2 (G), Q14.2 (G), R13.2, SW1.3 (C)
B: Q1.5 (G), Q2.5 (G), Q3.5 (G), Q4.5 (G), Q5.5 (G), Q6.5 (G), Q7.5 (G), Q8.5 (G), Q9.5 (G), Q10.5 (G), Q11.5 (G), Q12.5 (G), Q13.5 (G), Q14.5 (G), R12.2, SW1.1 (A)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, D1.1 (K), D2.1 (K), J1.8, R9.1, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND)
IR1: C2.2, J1.7, Q1.1 (S), R2.2
IR2: C4.2, J1.9, Q2.1 (S), R4.2
IR3: C6.2, J1.11, Q3.1 (S), R6.2
IR4: C8.2, J1.13, Q4.1 (S), R8.2
IR5: C11.2, J1.15, Q5.1 (S), R11.2
IR6: C12.2, J1.16, Q6.1 (S), R15.2
IR7: C14.2, J1.14, Q7.1 (S), R17.2
IR8: C3.2, J1.12, Q8.1 (S), R1.2
IR9: C5.2, J1.6, Q9.1 (S), R3.2
IR10: C7.2, J1.4, Q10.1 (S), R5.2
IR11: C9.2, J1.2, Q11.1 (S), R7.2
IR12: C10.2, J1.1, Q12.1 (S), R10.2
IR13: C13.2, J1.3, Q13.1 (S), R14.2
IR14: C15.2, J1.5, Q14.1 (S), R16.2
unnamed: D1.2 (A), R12.1
unnamed: D2.2 (A), R13.1
unnamed: Q1.3 (D), Q1.6 (D), U1.1 (OUT)
unnamed: Q1.4 (S), R2.1
unnamed: Q2.3 (D), Q2.6 (D), U2.1 (OUT)
unnamed: Q2.4 (S), R4.1
unnamed: Q3.3 (D), Q3.6 (D), U3.1 (OUT)
unnamed: Q3.4 (S), R6.1
unnamed: Q4.3 (D), Q4.6 (D), U4.1 (OUT)
unnamed: Q4.4 (S), R8.1
unnamed: Q5.3 (D), Q5.6 (D), U5.1 (OUT)
unnamed: Q5.4 (S), R11.1
unnamed: Q6.3 (D), Q6.6 (D), U6.1 (OUT)
unnamed: Q6.4 (S), R15.1
unnamed: Q7.3 (D), Q7.6 (D), U7.1 (OUT)
unnamed: Q7.4 (S), R17.1
unnamed: Q8.3 (D), Q8.6 (D), U8.1 (OUT)
unnamed: Q8.4 (S), R1.1
unnamed: Q9.3 (D), Q9.6 (D), U9.1 (OUT)
unnamed: Q9.4 (S), R3.1
unnamed: Q10.3 (D), Q10.6 (D), U10.1 (OUT)
unnamed: Q10.4 (S), R5.1
unnamed: Q11.3 (D), Q11.6 (D), U11.1 (OUT)
unnamed: Q11.4 (S), R7.1
unnamed: Q12.3 (D), Q12.6 (D), U12.1 (OUT)
unnamed: Q12.4 (S), R10.1
unnamed: Q13.3 (D), Q13.6 (D), U13.1 (OUT)
unnamed: Q13.4 (S), R14.1
unnamed: Q14.3 (D), Q14.6 (D), U14.1 (OUT)
unnamed: Q14.4 (S), R16.1

Board: 2 copper layers, 189.9 x 157.6 mm, 65 parts (1 on the bottom side), 48 nets.

Other parts of the board:
MH: MountingHole_4.3mm_M4

## KiCad design Main_Board/Main_Board.kicad_pcb

Board: 4 copper layers, 120.0 x 140.0 mm, 79 parts (10 on the bottom side), 87 nets.

Parts:
3.3V, 12V: TestPoint_Pad_D1.0mm
C1: 10u; C_1210_3225Metric
C2: 470n; C_0603_1608Metric
C3: 4.7u; C_0603_1608Metric
C4: 100n; C_0603_1608Metric
C5: 75n; C_0603_1608Metric
C6, C7: 22u; C_1210_3225Metric
C8: 1u; C_0603_1608Metric
C9: 220n; C_0603_1608Metric
D1, D10, D11: LED; LED_0805_2012Metric
D2, D3, D4, D5, D6, D7, D8, D9: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D12: 20V; D_SOD-123
ECHO_L: TestPoint_Pad_D1.0mm
ECHO_R: TestPoint_Pad_D1.0mm
J1, J2, J3: Conn_01x06; JST_EH_S6B-EH_1x06_P2.50mm_Horizontal
J4: BATT_IN; AMASS_XT60PW-M
J5: Conn_02x08_Top_Bottom; Hirose_DF11-16DP-2DSA_2x08_P2.00mm_Vertical
J6: MAGN_CONN; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
J7: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J8: Conn_02x07_Counter_Clockwise; Hirose_DF11-14DP-2DSA_2x07_P2.00mm_Vertical
J9: HR-SR04_R_CONN; PinSocket_1x04_P2.54mm_Vertical
J10: HR-SR04_L_CONN; PinSocket_1x04_P2.54mm_Vertical
J11: 12V_OUT; 215760-YY04
J12: BATT_REG_IN; 215760-YY04
J13: LED_CONN; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J14: PD_CONN; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
L1: 2.2u; Bours_SRP4020FA
M1_PWM, M2_PWM, M3_PWM: TestPoint_Pad_D1.0mm
M4, M4#2: MountingHole_4.3mm_M4
Q1, Q2: SISS65DN-T1-GE3; Vishay_PowerPAK_1212-8_Single
R1: 234R; R_0603_1608Metric
R2, R5, R8, R14, R18, R19: 100k; R_0603_1608Metric
R3, R4, R7, R15: 10k; R_0805_2012Metric
R6: 3.3R; R_0603_1608Metric
R9: 17k5; R_0805_2012Metric
R10: 2k; R_0603_1608Metric
R11: 34k7; R_0603_1608Metric
R12: 20R; R_0805_2012Metric
R13: 5k6; R_0805_2012Metric
R16: 520R; R_0603_1608Metric
R17: 70R; R_0603_1608Metric
SW1, SW4: SW_SPDT; EG1218
SW2: SW_Push; EVP-BT2J4A000
SW3: EN; EG1218
TRIG_L: TestPoint_Pad_D1.0mm
TRIG_R: TestPoint_Pad_D1.0mm
U1: TEENSY_4_1_MASTER; TEENSY_4_1_FP
U2: TEENSY_4_1_SLAVE; TEENSY_4_1_FP
U3, U4, U5: G2-24v13
U6: SiC467ED; Vishay_PowerPAK_MLP55-27L_ThermalVias
VBAT: TestPoint_Pad_D1.0mm

Connections:
+3V3: 3.3V.1, C6.1, C7.1, C9.1, D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), J5.8, J6.1, J7.2, J8.13, J8.14, J9.1, J10.1, J14.1, L1.2, R9.1, R12.2, R17.1, SW2.2, U1.VIN, U2.VIN, U6.20 (Vout)
+12V: Q1.3 (S), R1.1, R19.2, U3.4 (VIN), U4.4 (VIN), U5.4 (VIN)
+VDC: C1.1, C2.1, D12.1 (K), J12.1, Q2.3 (S), R2.2, R16.1, SW3.1 (A), U6.1 (VCIN), U6.7 (VIN), U6.8 (VIN), U6.29 (VINPAD), VBAT.1
D: J8.1, U2.27 (A13)
ECHO_L: ECHO_L.1, J10.3, U2.9 (OUT1C)
ECHO_R: ECHO_R.1, J9.3, U2.38 (A14)
GND: C1.2, C2.2, C3.2, C5.1, C6.2, C7.2, C8.1, C9.2, D1.1 (K), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.1 (K), D11.1 (K), J4.1 (-), J5.10, J6.4, J7.1, J8.5, J8.8, J9.4, J10.4, J11.2, J12.2, J13.2, R4.1, R5.2, R7.1, R10.1, R11.1, R13.1, R14.2, R18.2, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U2.GND1 (GND), U2.GND2 (GND), U2.GND3 (GND), U3.1 (GND), U3.5 (GND), U4.1 (GND), U4.5 (GND), U5.1 (GND), U5.5 (GND), U6.9 (PGND), U6.10 (PGND), U6.11 (PGND), U6.17 (PGND), U6.23 (AGND), U6.28 (AGND-PAD), U6.30 (PGND-PAD)
HOLD_SW: R4.2, SW2.1, U2.28 (RX7)
IR1: J5.9, U1.17 (A3)
IR2: J5.7, U1.16 (A2)
IR3: J5.5, U1.14 (A0)
IR4: J5.3, U1.40 (A16)
IR5: J5.1, U1.38 (A14)
IR6: J5.2, U1.39 (A15)
IR7: J5.4, U1.41 (A17)
IR8: J5.6, U1.15 (A1)
IR9: J5.12, U1.18 (A4)
IR10: J5.14, U1.24 (A10)
IR11: J5.16, U1.26 (A12)
IR12: J5.15, U1.27 (A13)
IR13: J5.13, U1.25 (A11)
IR14: J5.11, U1.19 (A5)
LED_DIN: D2.4 (DIN), U2.0 (RX1)
M1_A: J1.1, U3.3 (OUTA)
M1_B: J1.2, U3.2 (OUTB)
M1_DIR: U2.1 (TX1), U3.6 (DIR)
M1_PWM: M1_PWM.1, U2.2 (OUT2), U3.7 (PWM)
M2_A: J2.1, U4.3 (OUTA)
M2_B: J2.2, U4.2 (OUTB)
M2_DIR: U2.22 (A8), U4.6 (DIR)
M2_PWM: M2_PWM.1, U2.23 (A9), U4.7 (PWM)
M3_A: J3.1, U5.3 (OUTA)
M3_B: J3.2, U5.2 (OUTB)
M3_DIR: U2.24 (A10), U5.6 (DIR)
M3_PWM: M3_PWM.1, U2.25 (A11), U5.7 (PWM)
MAGN_SCL: J6.3, U2.19 (A5)
MAGN_SDA: J6.2, U2.18 (A4)
unnamed: C3.1, U6.16 (VDRV)
unnamed: C4.1, U6.4 (BOOT)
unnamed: C4.2, R6.2
unnamed: C5.2, U6.19 (SS)
unnamed: C8.2, R8.1, U6.25 (Ilimit), U6.26 (VDD)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (A), R16.2
unnamed: D11.2 (A), R17.2
unnamed: D12.2 (A), R18.1, SW4.3 (C)
unnamed: J4.2 (+), Q2.2 (D)
unnamed: J11.1, Q1.2 (D)
unnamed: J13.1, R12.1
unnamed: L1.1, U6.12 (SW), U6.13 (SW), U6.14 (SW)
unnamed: Q1.1 (G), R15.1
unnamed: Q2.1 (G), R3.1
unnamed: R2.1, SW4.1 (A)
unnamed: R3.2, SW4.2 (B)
unnamed: R5.1, SW3.2 (B), U6.3 (EN)
unnamed: R6.1, U6.5 (PHASE), U6.6 (PHASE)
unnamed: R8.2, U6.2 (PGOOD)
unnamed: R10.2, U6.27 (Mode)
unnamed: R11.2, U6.24 (FSW)
unnamed: R9.2, R13.2, U6.22 (VFB)
unnamed: R14.1, SW1.3 (C)
unnamed: R15.2, SW1.2 (B)
unnamed: R19.1, SW1.1 (A)
unnamed: U1.10 (CS1), U2.10 (CS1)
unnamed: U1.11 (MOSI), U2.11 (MOSI)
unnamed: U1.12 (MISO), U2.12 (MISO)
OLED_SCL: J7.7, U2.16 (A2)
OLED_SDA: J7.8, U2.17 (A3)
P0: J8.12, U2.33 (MCLK2)
P1: J8.11, U2.34 (RX8)
P2: J8.10, U2.35 (TX8)
P3: J8.9, U2.36 (CS2)
P4: J8.7, U2.29 (TX7)
PD_OUT: J14.2, R7.2, U2.21 (A7)
SCK_MASTER: U1.13 (SCK), U2.13 (SCK)
TRIG_L: J10.2, TRIG_L.1, U2.8 (TX2)
TRIG_R: J9.2, TRIG_R.1, U2.39 (A15)
~CS: J8.6, U2.30 (CRX3)
~EN: J8.4, U2.32 (OUT1B)
~WR: J8.3, U2.31 (CTX3)

## KiCad design Light_Ring_PCB/Light_Ring_PCB.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C26: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_0603_1608Metric
J1: LIGHT_OUT; Hirose_DF11-14DP-2DSA_2x07_P2.00mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24: Q_Photo_NPN; XDCR_ALS-PT19-315C_L177_TR8
Q25: EN; SOT-23
R1, R2, R3, R4, R9, R10, R11, R12, R17, R18, R19, R20, R25, R26, R27, R28, R33, R34, R37, R38, R41, R42, R45, R46: 6k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7, R8, R13, R14, R15, R16, R21, R22, R23, R24, R29, R30, R31, R32, R35, R36, R39, R40, R43, R44, R47, R48: 12R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R49: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: ADG732; LFCSP-48-1EP_7x7mm_P0.5mm_EP4.1x4.1mm

Connections:
+3V3: C25.1, C26.1, J1.1, J1.2, Q1.1 (C), Q2.1 (C), Q3.1 (C), Q4.1 (C), Q5.1 (C), Q6.1 (C), Q7.1 (C), Q8.1 (C), Q9.1 (C), Q10.1 (C), Q11.1 (C), Q12.1 (C), Q13.1 (C), Q14.1 (C), Q15.1 (C), Q16.1 (C), Q17.1 (C), Q18.1 (C), Q19.1 (C), Q20.1 (C), Q21.1 (C), Q22.1 (C), Q23.1 (C), Q24.1 (C), R5.1, R6.1, R7.1, R8.1, R13.1, R14.1, R15.1, R16.1, R21.1, R22.1, R23.1, R24.1, R29.1, R30.1, R31.1, R32.1, R35.1, R36.1, R39.1, R40.1, R43.1, R44.1, R47.1, R48.1, U1.13 (Vdd), U1.14 (Vdd)
D: J1.13, U1.43 (D)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), Q25.3 (S), R1.2, R2.2, R3.2, R4.2, R9.2, R10.2, R11.2, R12.2, R17.2, R18.2, R19.2, R20.2, R25.2, R26.2, R27.2, R28.2, R33.2, R34.2, R37.2, R38.2, R41.2, R42.2, R45.2, R46.2, R49.2, U1.23 (GND), U1.24 (Vss), U1.49
L1: C1.1, Q1.2 (E), R1.1, U1.8 (S5)
L2: C2.1, Q2.2 (E), R2.1, U1.7 (S6)
L3: C3.1, Q3.2 (E), R3.1, U1.6 (S7)
L4: C4.1, Q4.2 (E), R4.1, U1.5 (S8)
L5: C5.1, Q5.2 (E), R9.1, U1.4 (S9)
L6: C6.1, Q6.2 (E), R10.1, U1.3 (S10)
L7: C7.1, Q7.2 (E), R11.1, U1.2 (S11)
L8: C8.1, Q8.2 (E), R12.1, U1.1 (S12)
L9: C9.1, Q9.2 (E), R17.1, U1.36 (S28)
L10: C10.1, Q10.2 (E), R18.1, U1.35 (S27)
L11: C11.1, Q11.2 (E), R19.1, U1.34 (S26)
L12: C12.1, Q12.2 (E), R20.1, U1.33 (S25)
L13: C13.1, Q13.2 (E), R25.1, U1.32 (S24)
L14: C14.1, Q14.2 (E), R26.1, U1.31 (S23)
L15: C15.1, Q15.2 (E), R27.1, U1.30 (S22)
L16: C16.1, Q16.2 (E), R28.1, U1.29 (E)
L17: C17.1, Q17.2 (E), R33.1, U1.28 (S20)
L18: C18.1, Q18.2 (E), R34.1, U1.27 (S19)
L19: C19.1, Q19.2 (E), R37.1, U1.26 (S18)
L20: C20.1, Q20.2 (E), R38.1, U1.25 (S17)
L21: C21.1, Q21.2 (E), R41.1, U1.12 (S1)
L22: C22.1, Q22.2 (E), R42.1, U1.11 (S2)
L23: C23.1, Q23.2 (E), R45.1, U1.10 (S3)
L24: C24.1, Q24.2 (E), R46.1, U1.9 (S4)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R13.2
unnamed: D6.2 (A), R14.2
unnamed: D7.2 (A), R15.2
unnamed: D8.2 (A), R16.2
unnamed: D9.2 (A), R21.2
unnamed: D10.2 (A), R22.2
unnamed: D11.2 (A), R23.2
unnamed: D12.2 (A), R24.2
unnamed: D13.2 (A), R29.2
unnamed: D14.2 (A), R30.2
unnamed: D15.2 (A), R31.2
unnamed: D16.2 (A), R32.2
unnamed: D17.2 (A), R35.2
unnamed: D18.2 (A), R36.2
unnamed: D19.2 (A), R39.2
unnamed: D20.2 (A), R40.2
unnamed: D21.2 (A), R43.2
unnamed: D22.2 (A), R44.2
unnamed: D23.2 (A), R47.2
unnamed: D24.2 (A), R48.2
unnamed: J1.8, J1.9, Q25.2 (D)
P0: J1.4, U1.15 (A0)
P1: J1.3, U1.16 (A1)
P2: J1.6, U1.17 (A2)
P3: J1.5, U1.18 (A3)
P4: J1.7, U1.19 (A4)
PCB_EN: J1.14, Q25.1 (G), R49.1
~CL: J1.10, U1.20 (~CS)
~EN: J1.12, U1.22 (~EN)
~WR: J1.11, U1.21 (~WR)

Notes on the sheet:
IF Vf = 3.1V, then Rled = 12R IF Vf = 2.9V, then Rled = 25R

Board: 2 copper layers, 120.0 x 120.0 mm, 126 parts (5 on the bottom side), 61 nets.
