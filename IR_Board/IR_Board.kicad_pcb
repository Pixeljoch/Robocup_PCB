# Repository Pixeljoch/Robocup_PCB (continued)

## KiCad design LiPo_12_Driver/LiPo_12_Driver.kicad_pcb

Parts:
C1, C2: 47u; CP_Elec_6.3x7.7
C3, C4: 10u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C5: 0.47; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6: 63n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7, C8, C14: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9: 220p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C10: 150p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C11: 40n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C12: 0.1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C13: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C15: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C16, C17, C18: 330u; CP_Elec_6.3x9.9
C19, C20, C21, C24, C25, C26, C27: 22u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C22, C23: 0.47u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D5: 470mV, 500mA; D_SOD-123
D3: 1V, 10A; TO-252-2
D4: 1V, 1.6A; D_SMA_Handsoldering
J1: M+; PinHeader_1x01_P2.54mm_Vertical
J2, J4: GND; PinHeader_1x01_P2.54mm_Vertical
J3: VIN+; PinHeader_1x01_P2.54mm_Vertical
L1, L2: 4.7u; L_Vishay_IHLP-6767
Q1, Q2, Q3: Q_NMOS; VSONP-8-1EP_5x6_P1.27mm
Q4, Q5, Q6, Q7: Q_NMOS; VSON-8_3.3x3.3mm_P0.65mm_NexFET
R1: 129.7k; R_0402_1005Metric
R2: 280k; R_0402_1005Metric
R3: 67.7k; R_0402_1005Metric
R4, R7: 20k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5, R9, R10: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 5.44k; R_0402_1005Metric
R8: 280k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11: 2.5m; R_2816_7142Metric_Pad3.20x4.45mm_HandSolder
R12: 93.1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: TI_LM5175; QFN-28-1EP_4x5mm_P0.5mm_EP2.65x3.65mm_ThermalVias

Connections:
+VDC: C1.1, C2.1, C3.1, C4.1, C5.1, D1.2 (A), J3.1, Q1.3 (D), Q2.3 (D), R2.1, U1.3
BOOT2: C15.1, D5.1 (K), U1.20
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C12.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, J2.1, J4.1, R1.2, R3.2, R6.2, R7.2, R10.1, R11.2, R12.1, U1.5, U1.10, U1.13, U1.14, U1.22, U1.29
HDRV2: Q4.2 (G), Q5.2 (G), U1.19
LDRV2: Q6.2 (G), Q7.2 (G), U1.21
unnamed: C6.2, U1.8
unnamed: C7.2, U1.24
unnamed: C8.2, U1.23
unnamed: C10.2, U1.7
unnamed: C11.1, R6.1
unnamed: C9.2, C11.2, U1.9
unnamed: C12.2, R5.2, U1.2
unnamed: C13.1, D3.1 (K), L1.1, L2.1, Q1.1 (S), Q2.1 (S), Q3.3 (D), U1.28
unnamed: C13.2, D2.1 (K), U1.26
unnamed: C14.1, R10.2, U1.15
unnamed: C14.2, R9.2, U1.16
unnamed: D1.1 (K), R5.1
unnamed: D3.2 (A), Q3.1 (S), Q6.1 (S), Q7.1 (S), R9.1, R11.1
unnamed: Q1.2 (G), Q2.2 (G), U1.27
unnamed: Q3.2 (G), U1.25
unnamed: R1.1, U1.6
unnamed: R2.2, R3.1, U1.1
unnamed: R4.1, U1.17
unnamed: R7.1, R8.1, U1.11
unnamed: R12.2, U1.4
PGOOD: D2.2 (A), D5.2 (A), R4.2
SW2: C15.2, D4.2 (A), L1.2, L2.2, Q4.1 (S), Q5.1 (S), Q6.3 (D), Q7.3 (D), U1.18
VOSNS: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, D4.1 (K), J1.1, Q4.3 (D), Q5.3 (D), R8.2, U1.12

Board: 2 copper layers, 90.4 x 51.6 mm, 58 parts (0 on the bottom side), 28 nets.

## KiCad design Robocup_PCB.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C13: 10n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: 1N5347B; D_DO-201_P15.24mm_Horizontal
D2: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
IR1, IR2, IR3, IR4, IR5, IR6, IR7, IR8, IR9, IR10, IR11, IR12: TSSP93038; IR_TSOP93038_TH
J1: M1_IN; PinSocket_1x06_P2.54mm_Vertical
J2: M2_IN; PinSocket_1x06_P2.54mm_Vertical
J3: M3_IN; PinSocket_1x06_P2.54mm_Vertical
J4: Arduino_Mega_Header; arduino_mega_header
J8: XT60-M; AMASS_XT60-M; PARTREV 1.2
Q1: IRF9540N; TO-263-2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 6k2; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R13: 100k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R14, R15: 680R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R16: 180R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1, SW2, SW3: SS ESP101; PinSocket_1x03_P2.54mm_Vertical
U1, U2, U5: TB6612FNG_MOD; U_TB6612FNG_MOD
U3: 5V_D24V5F5
U4: 12V_S18V20F12; 12_S18V20F12_FP

Connections:
+3V3: IR1.3 (Vs), IR2.3 (Vs), IR3.3 (Vs), IR4.3 (Vs), IR5.3 (Vs), IR6.3 (Vs), IR7.3 (Vs), IR8.3 (Vs), IR9.3 (Vs), IR10.3 (Vs), IR11.3 (Vs), IR12.3 (Vs), J4.4 (3.3V)
+5V: J1.4, J2.4, J3.4, J4.5 (5V), R16.1, U1.4 (STBY), U1.15 (VCC), U2.4 (STBY), U2.15 (VCC), U3.4 (VOUT), U5.4 (STBY), U5.15 (VCC)
+12V: R14.1, U1.10 (VMOT), U2.10 (VMOT), U4.4 (VOUT), U5.10 (VMOT)
A0: C1.2, J4.9 (AD0), R1.2
A1: C2.2, J4.10 (AD1), R2.2
A2: C3.2, J4.11 (AD2), R3.2
A3: C4.2, J4.12 (AD3), R4.2
A4: C5.2, J4.13 (AD4), R5.2
A5: C6.2, J4.14 (AD5), R6.2
A6: C7.2, J4.15 (AD6), R7.2
A7: C8.2, J4.16 (AD7), R8.2
A8: C9.2, J4.17 (AD8), R9.2
A9: C10.2, J4.18 (AD9), R10.2
A10: C11.2, J4.19 (AD10), R11.2
A11: C12.2, J4.20 (AD11/TXD3), R12.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, D2.1 (K), D3.1 (K), D4.1 (K), IR1.2 (GND), IR2.2 (GND), IR3.2 (GND), IR4.2 (GND), IR5.2 (GND), IR6.2 (GND), IR7.2 (GND), IR8.2 (GND), IR9.2 (GND), IR10.2 (GND), IR11.2 (GND), IR12.2 (GND), J1.3, J2.3, J3.3, J4.6 (GND), J8.1 (-), R13.2, SW1.2 (B), U1.8 (GND), U1.9 (GND), U1.16 (GND), U2.8 (GND), U2.9 (GND), U2.16 (GND), U3.3 (GND), U4.1 (GND), U4.5 (GND), U5.8 (GND), U5.9 (GND), U5.16 (GND); also elsewhere on the board
M1_A: J1.1, U1.14 (AO1)
M1_AIN1: J4.59 (PIN23), U1.3 (AIN1)
M1_AIN2: J4.58 (PIN25), U1.2 (AIN2)
M1_B: J1.2, U1.13 (AO2)
M1_ENA: J1.5, J4.64 (TXD2/18)
M1_ENB: J1.6, J4.41 (PIN22)
M1_PWMA: J4.73 (SS1/PWM4/SD-CS/4), U1.1 (PWMA)
M2_A: J2.1, U2.12 (BO2)
M2_B: J2.2, U2.11 (BO1)
M2_BIN1: J4.57 (PIN27), U2.5 (BIN1)
M2_BIN2: J4.56 (PIN29), U2.6 (BIN2)
M2_ENA: J2.5, J4.63 (RXD2/19)
M2_ENB: J2.6, J4.40 (PIN24)
M2_PWMB: J4.76 (PWM7/7), U2.7 (PWMB)
M3_A: J3.1, U5.14 (AO1)
M3_AIN1: J4.55 (PIN31), U5.3 (AIN1)
M3_AIN2: J4.54 (PIN33), U5.2 (AIN2)
M3_B: J3.2, U5.13 (AO2)
M3_ENA: J3.5, J4.62 (SDA0-3/TWD1/20)
M3_ENB: J3.6, J4.39 (PIN26)
M3_PWMA: J4.79 (SS0/PWM10/ETH-CS/10), U5.1 (PWMA)
unnamed 37: C13.1, SW1.1 (A), U4.3 (EN); also elsewhere on the board
unnamed 38: D1.1 (K), R15.1, SW3.2 (B); also elsewhere on the board
unnamed: D1.2 (A), Q1.1 (G), R13.1
unnamed: D2.2 (A), R14.2
unnamed: D3.2 (A), R15.2
unnamed: D4.2 (A), R16.2
unnamed: IR1.1 (OUT), R1.1
unnamed: IR2.1 (OUT), R2.1
unnamed: IR3.1 (OUT), R3.1
unnamed: IR4.1 (OUT), R4.1
unnamed: IR5.1 (OUT), R5.1
unnamed: IR6.1 (OUT), R6.1
unnamed: IR7.1 (OUT), R7.1
unnamed: IR8.1 (OUT), R8.1
unnamed: IR9.1 (OUT), R9.1
unnamed: IR10.1 (OUT), R10.1
unnamed: IR11.1 (OUT), R11.1
unnamed: IR12.1 (OUT), R12.1
unnamed: J8.2 (+), Q1.2 (D)
unnamed 111: Q1.3 (S), SW2.3 (C), SW3.3 (C), U4.2 (VIN); also elsewhere on the board
unnamed 114: SW2.2 (B), U3.2 (VIN); also elsewhere on the board

Board: 2 copper layers, 209.8 x 196.2 mm, 59 parts (0 on the bottom side), 58 nets.

Other parts of the board:
SW_ARD: SS ESP101; PinSocket_1x03_P2.54mm_Vertical
SW_M: SS ESP101; PinSocket_1x03_P2.54mm_Vertical
SW_P: SS ESP101; PinSocket_1x03_P2.54mm_Vertical

Their connections:
GND: SW_M.2; also elsewhere on the board
unnamed 37: SW_M.1; also elsewhere on the board
unnamed 38: SW_P.2; also elsewhere on the board
unnamed 111: SW_ARD.3, SW_P.3; also elsewhere on the board
unnamed 114: SW_ARD.2; also elsewhere on the board

## Commit log

2021-01-03 first push
2021-01-07 Finished schematic, started PCB Design
2021-01-07 Redid power management, more efficient
2021-01-08 Parts given Footprints
2021-01-10 BOM list generated
2021-01-10 Finished PCB, Generated Gerbers
2021-03-11 restored
2021-03-11 5V regulator done
2021-04-08 Started Light PCB
2021-04-08 Some small corrections
2021-04-10 Started MUX
2021-04-12 Finished MUX
2021-04-14 Finished Motor Drivers
2021-04-15 Finished Light Ring Schematic
2021-04-22 Started PCB
2021-09-07 Finished LiPo balancer schematic
2021-10-20 Finished LIPO Driver
2021-10-22 Finished LIPO Schematic, started PCB design
2021-10-22 more lipo pcb dev
2021-10-26 More LIPO PCB development
2021-10-27 Almost finished LIPO PCB
2021-10-30 Finished LIPO Driver PCB
2021-10-30 Small updates, Ready for order
2021-10-31 Updated PCB because QFN package is out of stockaslhdflsakghlksa
2021-11-05 LIPO gerbers generated
2021-11-09 Organized Files for Next PCBs
2021-11-27 updated some stuff
2021-11-27 IR schematic complete
2021-12-23 Started Main Board
2022-01-10 Rounding up main and light board
2022-01-14 Stuff with light
2022-01-14 motor drivers added
2022-01-21 changed document settings
2022-01-21 Added all connectors, layout for pins
2022-01-25 old stuff
2022-01-25 Started connecting main board
2022-01-26 started buck CC driver for LPCB
2022-01-28 Finished LightPCB
2022-01-30 Finished Light PCB
2022-01-31 Finalizing Main PCB Sch
2022-02-01 Started Main PCB
2022-02-01 Finalized Pin layout, started redesigned Buck
2022-02-03 added light gate
2022-02-04 Finished Main PCB schematic
2022-02-04 Some small alterations to the main pcb sch
2022-02-05 Started Main PCB Drawing
2022-02-07 Finished Power Planes and layout, started drawing traces [MAIN BOARD]
2022-02-07 Small changes to 12V connector [MAIN BOARD]
2022-02-08 Started actual traces [MAIN BOARD]
2022-02-09 Finished main part traces [MAIN_PCB]
2022-02-09 Finished board [MAIN BOARD]
2022-02-10 Finished DRC [MAIN BOARD]
2022-02-11 Started IR PCB
2022-02-13 Updated to Kicad 6
2022-02-15 Progress with pcb [IR BOARD]
2022-02-15 Started drawing traces [IR BOARD]
2022-02-16 Continued drawing traces [IR BOARD]
2022-02-16 Finished IR, generated gerbers, ordered designs
2022-02-17 Changed .wrl to .step
2022-02-22 Small tweaks
2022-03-08 Updated PLOT
2022-03-08 made pdf for LIGHT PCB
